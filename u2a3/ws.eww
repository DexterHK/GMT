<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\u3a3.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\u3a4\u3a4.ewp</path>
    </project>
    <batchBuild />
</workspace>
